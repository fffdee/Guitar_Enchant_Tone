# Keil uVision project Project.uvprojx, settings and files
target STM3210E-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E-EVAL
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --C99
  c include: ../inc;../../../../Libraries/CMSIS/Device/ST/STM32F10x/Include;../../../../Libraries\STM32F10x_StdPeriph_Driver\inc;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM3210E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../src/: stm32_it.c main.c bsp_wm8978.c
  group STM32F10x/CMSIS
    ./: startup_stm32f10x_hd.s
    ../src/: system_stm32f10x.c
  group Doc
    ../: readme.txt
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_sdio.c
  group STM32F10x/STM3210E_EVAL
    ../../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c
software components: CMSIS:CORE 5.3.0
